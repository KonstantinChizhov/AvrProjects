# IAR project ArmTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD_VL
  ICCARM.CCIncludePath2: ../mcucpp; ../mcucpp/ARM/STM32
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: E:\Projects\McuProjects\Stm32Timers\ArmTest.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F10X_MD_VL
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: ArmTest.bin
  ILINK.IlinkIcfFile: ArmTest.icf
  group (top)
    ./: main.cpp
